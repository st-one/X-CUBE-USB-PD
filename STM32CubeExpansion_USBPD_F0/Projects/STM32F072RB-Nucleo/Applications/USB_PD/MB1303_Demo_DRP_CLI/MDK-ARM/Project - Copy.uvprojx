# Keil uVision project Project - Copy.uvprojx, settings and files
target STM32F072RB-Nucleo_MB1303_Demo_DRP_CLI (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO,_RTOS,USBPD_LED_SERVER,USBPD_PORT_COUNT=2,_DRP,_SNK,MB1303,USE_FULL_LL_DRIVER,USBPD_STUSB1602,CONF_NORMAL,USBPDCORE_LIB_PD2_CONFIG_1,_ERROR_RECOVERY,USBPD_CLI
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx-Nucleo;../../../../../../Drivers/BSP/P-NUCLEO-USB002;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/STUSB1602;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602/inc;../../../../../../Utilities/LED_SERVER;../../../../../../Utilities/CLI_USER
  asm include: ../Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Application/User
    ../Src/: usbpd_dpm_user.c stm32f0xx_hal_msp.c main.c usbpd_pwr_if.c stm32f0xx_it.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c
  group Utilities/CLI_RTOS
    ../../../../../../Utilities/CLI_RTOS/: FreeRTOS_CLI.c
  group Utilities/CLI_USER
    ../../../../../../Utilities/CLI_USER/: cli_commands.c cli_user.c cli_console.c
  group Drivers/BSP/P-NUCLEO-USB002
    ../../../../../../Drivers/BSP/P-NUCLEO-USB002/: p-nucleo-usb002.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_crc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_crc_ex.c stm32f0xx_ll_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart_ex.c stm32f0xx_ll_utils.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_rcc_ex.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPD_CORE_CM0_PD2_CONFIG_1_Keil.lib
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602/src/: usbpd_cad_hw_if.c usbpd_stusb16xx_hw_if.c usbpd_timersserver.c bmc.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_phy.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/Components/STUSB1602
    ../../../../../../Drivers/BSP/Components/STUSB1602/: STUSB1602_Driver.c
  group Utilities/LED_SERVER
    ../../../../../../Utilities/LED_SERVER/: led_server.c
software components: CMSIS:CORE 4.3.0

# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo_Provider_VDM_RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO,USBPD_VDM_ENABLED,_RTOS,USBPD_LED_SERVER,USBPD_PORT_COUNT=1,_SRC,USBPDCORE_LIB_PD2_FULL,_TRACE_NA
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx-Nucleo;../../../../../../Drivers/BSP/P-NUCLEO-USB001;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32F072/inc;../../../../../../Utilities/LED_SERVER
  asm include: ../Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/BSP/P-NUCLEO-USB001
    ../../../../../../Drivers/BSP/P-NUCLEO-USB001/: p-nucleo-usb001.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_comp.c stm32f0xx_ll_utils.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_cortex.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbpd_dpm_user.c usbpd_vdm_user.c usbpd_pwr_if.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c tasks.c list.c
  group Utilities/LED_SERVER
    ../../../../../../Utilities/LED_SERVER/: led_server.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD2_FULL_CM0_Keil.lib
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: usbpd_bsp_trace.c stm32f0xx_nucleo.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32F072
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32F072/src/: usbpd_pwr_hw_if.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_timersserver.c bmc.c usbpd_cad_hw_if.c usbpd_phy.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0

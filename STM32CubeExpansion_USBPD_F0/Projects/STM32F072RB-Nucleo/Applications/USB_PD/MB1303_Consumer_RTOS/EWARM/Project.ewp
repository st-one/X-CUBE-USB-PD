# IAR project Project.ewp, settings and files
configuration STM32F072RB-Nucleo (ARM)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MB1303; STM32F072xB; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; USE_STM32F0XX_NUCLEO; __PE_DUALPORT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F0xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-USB002; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STUSB1602\inc; ..\..\..\..\..\..\Utilities\LED_SERVER; ..\..\..\..\..\..\Utilities\CLI_USER; ..\..\..\..\..\..\Drivers\BSP\Components\STUSB1602
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: MB1303_Sink_1P_RTOS.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usbpd_dpm.c usbpd_pwr_if.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/STUSB1602
    ../../../../../../Drivers/BSP/Components/STUSB1602/: STUSB1602_Driver.c
  group Drivers/BSP/P-NUCLEO_USB002
    ../../../../../../Drivers/BSP/P-NUCLEO-USB002/: p-nucleo-usb002.c
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c
  group Middlewares/ST/STM32_USBPD_Library
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPD_CORE1602_CM0_NOVDM_1PORT_IAR.a
  group Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STUSB1602/src/: usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_stusb16xx_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Utilities/CLI_RTOS
    ../../../../../../Utilities/CLI_RTOS/: FreeRTOS_CLI.c
  group Utilities/CLI_USER
    ../../../../../../Utilities/CLI_USER/: cli_commands.c cli_console.c cli_user.c
  group Utilities/LED_SERVER
    ../../../../../../Utilities/LED_SERVER/: led_server.c

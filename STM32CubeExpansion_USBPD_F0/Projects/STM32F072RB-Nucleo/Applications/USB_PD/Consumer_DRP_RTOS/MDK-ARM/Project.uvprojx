# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072RB-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F0xx-Nucleo;../../../../../../Drivers/BSP/P-NUCLEO-USB001;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USBPD_Library/devices/STM32F072/inc;../../../../../../Utilities/LED_SERVER
  asm include: ROJ_DIR$\..\Inc;ROJ_DIR$\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart.c stm32f0xx_hal_comp.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_crc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_crc_ex.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c queue.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/BSP/P-NUCLEO-USB001
    ../../../../../../Drivers/BSP/P-NUCLEO-USB001/: p-nucleo-usb001.c
  group Utilities/LED_SERVER
    ../../../../../../Utilities/LED_SERVER/: led_server.c
  group Middlewares/ST/STM32_USBPD_Library
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32F072/lib/: USBPD_DEVICE_STM32072_1PORT_KEIL.lib
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPD_CORE_CM0_NOVDM_1PORT_KEIL.lib
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: usbpd_dpm.c usbpd_pwr_if.c stm32f0xx_it.c stm32f0xx_hal_msp.c main.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
software components: CMSIS:CORE 4.3.0
